inherit pkgconfig