
SRC_URI = "gitsm://github.com/google/draco.git;protocol=https;branch=gltf_2.0_draco_extension \
           file://0001-instrumentation.patch"